Commit message: kevinbot goal run

File: urdf/udacity_bot.xacro (robot description, xacro)
@@ -101,7 +101,4 @@
       </geometry>
     </visual>
-    <geometry>
-      <cylinder radius="0.1" length="0.05"/>
-    </geometry>
   </link>
   <joint type="continuous" name="left_wheel_hinge">
